# Enable openssl support
PACKAGECONFIG = "openssl"
